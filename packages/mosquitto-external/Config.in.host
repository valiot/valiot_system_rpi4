## packages/mosquitto-external/Config.in.host
```kconfig
config BR2_PACKAGE_HOST_MOSQUITTO_EXTERNAL
	bool "host mosquitto-external (mosquitto_passwd)"
	help
	  Only installs mosquitto_passwd.
```
